PACKAGECONFIG[jack] = ""
